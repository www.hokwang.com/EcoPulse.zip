Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EcoPulse碳刷版本.IFC
Time: 2026-07-29T06:21:22
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: EcoPulse_X2_底座
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EcoPulse__X2_59166bbc56fa5b9a7247_X0_
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EcoPulse__X2_59166bbc_X0_L_X2_677f_X0_
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: EcoPulse__X2_59166bbc_X0_U_X2_677f_X0_
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 輸入1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 輸入2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 輸入3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 輸入4
In: Default Storey
PredefinedType: ELEMENT
